v {xschem version=3.4.3 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {madvlsi/capacitor.sym} 90 -30 0 0 {name=C1
value=1p
m=1}
C {devices/gnd.sym} 90 0 0 0 {name=l2 lab=GND}
